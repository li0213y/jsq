# Keil uVision project 计算器.uvproj, settings and files
target 计算器 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 计算器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 计算器
    ./: 计算器.c lcd1602.c keyboard.c
